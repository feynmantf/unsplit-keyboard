.title KiCad schematic
C1 XTAL1 GND 22p
C2 XTAL2 GND 22p
C4 VCC GND 0.1u
C6 VCC GND 0.1u
C7 VCC GND 0.1u
C8 VCC GND 4.7u
SW1 GND RESET SW_PUSH
R1 RESET VCC 10k
R7 GND Net-_R7-Pad2_ 10k
C11 GND Net-_C11-Pad2_ 1u
R4 COL14 VCC 10k
C3 COL14 GND 0.1u
C10 GND ROT_B 0.1u
R5 VCC ROT_A 10k
R6 ROT_B VCC 10k
C9 ROT_A GND 0.1u
ENC1 ROT_A ROT_B GND COL14 R_ENC Rotary_Encoder_Switch
X1 XTAL1 XTAL2 GND XTAL
R2 D- Net-_R2-Pad2_ 22
R3 D+ Net-_R3-Pad2_ 22
USB1 GND VCC NC_01 NC_02 Net-_R2-Pad2_ Net-_R3-Pad2_ Net-_R2-Pad2_ Net-_R3-Pad2_ NC_03 NC_04 VCC GND GND HRO-TYPE-C-31-M-12
MX63 COL6 Net-_D63-Pad1_ MX-NoLED-MX_Alps_Hybrid
D63 Net-_D63-Pad1_ ROW4 D
MX62 COL3 Net-_D62-Pad1_ MX-NoLED-MX_Alps_Hybrid
D62 Net-_D62-Pad1_ ROW4 D
D61 Net-_D61-Pad1_ ROW4 D
MX61 COL1 Net-_D61-Pad1_ MX-NoLED-MX_Alps_Hybrid
D60 Net-_D60-Pad1_ ROW4 D
MX60 COL0 Net-_D60-Pad1_ MX-NoLED-MX_Alps_Hybrid
MX66 COL11 Net-_D66-Pad1_ MX-NoLED-MX_Alps_Hybrid
D66 Net-_D66-Pad1_ ROW4 D
MX69 COL14 Net-_D69-Pad1_ MX-NoLED-MX_Alps_Hybrid
D69 Net-_D69-Pad1_ ROW4 D
D68 Net-_D68-Pad1_ ROW4 D
MX68 COL13 Net-_D68-Pad1_ MX-NoLED-MX_Alps_Hybrid
MX53 COL8 Net-_D53-Pad1_ MX-NoLED-MX_Alps_Hybrid
D53 Net-_D53-Pad1_ ROW3 D
MX52 COL7 Net-_D52-Pad1_ MX-NoLED-MX_Alps_Hybrid
D52 Net-_D52-Pad1_ ROW3 D
D54 Net-_D54-Pad1_ ROW3 D
MX54 COL9 Net-_D54-Pad1_ MX-NoLED-MX_Alps_Hybrid
D51 Net-_D51-Pad1_ ROW3 D
MX51 COL6 Net-_D51-Pad1_ MX-NoLED-MX_Alps_Hybrid
D50 Net-_D50-Pad1_ ROW3 D
MX50 COL5 Net-_D50-Pad1_ MX-NoLED-MX_Alps_Hybrid
MX48 COL3 Net-_D48-Pad1_ MX-NoLED-MX_Alps_Hybrid
D48 Net-_D48-Pad1_ ROW3 D
MX47 COL2 Net-_D47-Pad1_ MX-NoLED-MX_Alps_Hybrid
D47 Net-_D47-Pad1_ ROW3 D
D49 Net-_D49-Pad1_ ROW3 D
MX49 COL4 Net-_D49-Pad1_ MX-NoLED-MX_Alps_Hybrid
D46 Net-_D46-Pad1_ ROW3 D
MX46 COL1 Net-_D46-Pad1_ MX-NoLED-MX_Alps_Hybrid
D45 Net-_D45-Pad1_ ROW3 D
MX45 COL0 Net-_D45-Pad1_ MX-NoLED-MX_Alps_Hybrid
MX57 COL12 Net-_D57-Pad1_ MX-NoLED-MX_Alps_Hybrid
D57 Net-_D57-Pad1_ ROW3 D
D56 Net-_D56-Pad1_ ROW3 D
MX56 COL11 Net-_D56-Pad1_ MX-NoLED-MX_Alps_Hybrid
D55 Net-_D55-Pad1_ ROW3 D
MX55 COL10 Net-_D55-Pad1_ MX-NoLED-MX_Alps_Hybrid
MX59 COL14 Net-_D59-Pad1_ MX-NoLED-MX_Alps_Hybrid
D59 Net-_D59-Pad1_ ROW3 D
D58 Net-_D58-Pad1_ ROW3 D
MX58 COL13 Net-_D58-Pad1_ MX-NoLED-MX_Alps_Hybrid
MX39 COL8 Net-_D39-Pad1_ MX-NoLED-MX_Alps_Hybrid
D39 Net-_D39-Pad1_ ROW2 D
MX38 COL7 Net-_D38-Pad1_ MX-NoLED-MX_Alps_Hybrid
D38 Net-_D38-Pad1_ ROW2 D
D40 Net-_D40-Pad1_ ROW2 D
MX40 COL9 Net-_D40-Pad1_ MX-NoLED-MX_Alps_Hybrid
D37 Net-_D37-Pad1_ ROW2 D
MX37 COL6 Net-_D37-Pad1_ MX-NoLED-MX_Alps_Hybrid
D36 Net-_D36-Pad1_ ROW2 D
MX36 COL5 Net-_D36-Pad1_ MX-NoLED-MX_Alps_Hybrid
MX34 COL3 Net-_D34-Pad1_ MX-NoLED-MX_Alps_Hybrid
D34 Net-_D34-Pad1_ ROW2 D
MX33 COL2 Net-_D33-Pad1_ MX-NoLED-MX_Alps_Hybrid
D33 Net-_D33-Pad1_ ROW2 D
D35 Net-_D35-Pad1_ ROW2 D
MX35 COL4 Net-_D35-Pad1_ MX-NoLED-MX_Alps_Hybrid
D32 Net-_D32-Pad1_ ROW2 D
MX32 COL1 Net-_D32-Pad1_ MX-NoLED-MX_Alps_Hybrid
D31 Net-_D31-Pad1_ ROW2 D
MX31 COL0 Net-_D31-Pad1_ MX-NoLED-MX_Alps_Hybrid
MX43 COL12 Net-_D43-Pad1_ MX-NoLED-MX_Alps_Hybrid
D43 Net-_D43-Pad1_ ROW2 D
D42 Net-_D42-Pad1_ ROW2 D
MX42 COL11 Net-_D42-Pad1_ MX-NoLED-MX_Alps_Hybrid
D41 Net-_D41-Pad1_ ROW2 D
MX41 COL10 Net-_D41-Pad1_ MX-NoLED-MX_Alps_Hybrid
D44 Net-_D44-Pad1_ ROW2 D
MX44 COL13 Net-_D44-Pad1_ MX-NoLED-MX_Alps_Hybrid
MX24 COL8 Net-_D24-Pad1_ MX-NoLED-MX_Alps_Hybrid
D24 Net-_D24-Pad1_ ROW1 D
MX23 COL7 Net-_D23-Pad1_ MX-NoLED-MX_Alps_Hybrid
D23 Net-_D23-Pad1_ ROW1 D
D25 Net-_D25-Pad1_ ROW1 D
MX25 COL9 Net-_D25-Pad1_ MX-NoLED-MX_Alps_Hybrid
D22 Net-_D22-Pad1_ ROW1 D
MX22 COL6 Net-_D22-Pad1_ MX-NoLED-MX_Alps_Hybrid
D21 Net-_D21-Pad1_ ROW1 D
MX21 COL5 Net-_D21-Pad1_ MX-NoLED-MX_Alps_Hybrid
MX19 COL3 Net-_D19-Pad1_ MX-NoLED-MX_Alps_Hybrid
D19 Net-_D19-Pad1_ ROW1 D
MX18 COL2 Net-_D18-Pad1_ MX-NoLED-MX_Alps_Hybrid
D18 Net-_D18-Pad1_ ROW1 D
D20 Net-_D20-Pad1_ ROW1 D
MX20 COL4 Net-_D20-Pad1_ MX-NoLED-MX_Alps_Hybrid
D17 Net-_D17-Pad1_ ROW1 D
MX17 COL1 Net-_D17-Pad1_ MX-NoLED-MX_Alps_Hybrid
D16 Net-_D16-Pad1_ ROW1 D
MX16 COL0 Net-_D16-Pad1_ MX-NoLED-MX_Alps_Hybrid
MX28 COL12 Net-_D28-Pad1_ MX-NoLED-MX_Alps_Hybrid
D28 Net-_D28-Pad1_ ROW1 D
D27 Net-_D27-Pad1_ ROW1 D
MX27 COL11 Net-_D27-Pad1_ MX-NoLED-MX_Alps_Hybrid
D26 Net-_D26-Pad1_ ROW1 D
MX26 COL10 Net-_D26-Pad1_ MX-NoLED-MX_Alps_Hybrid
MX30 COL14 Net-_D30-Pad1_ MX-NoLED-MX_Alps_Hybrid
D30 Net-_D30-Pad1_ ROW1 D
D29 Net-_D29-Pad1_ ROW1 D
MX29 COL13 Net-_D29-Pad1_ MX-NoLED-MX_Alps_Hybrid
MX9 COL8 Net-_D9-Pad1_ MX-NoLED-MX_Alps_Hybrid
D9 Net-_D9-Pad1_ ROW0 D
MX8 COL7 Net-_D8-Pad1_ MX-NoLED-MX_Alps_Hybrid
D8 Net-_D8-Pad1_ ROW0 D
D10 Net-_D10-Pad1_ ROW0 D
MX10 COL9 Net-_D10-Pad1_ MX-NoLED-MX_Alps_Hybrid
D7 Net-_D7-Pad1_ ROW0 D
MX7 COL6 Net-_D7-Pad1_ MX-NoLED-MX_Alps_Hybrid
D6 Net-_D6-Pad1_ ROW0 D
MX6 COL5 Net-_D6-Pad1_ MX-NoLED-MX_Alps_Hybrid
MX4 COL3 Net-_D4-Pad1_ MX-NoLED-MX_Alps_Hybrid
D4 Net-_D4-Pad1_ ROW0 D
MX3 COL2 Net-_D3-Pad1_ MX-NoLED-MX_Alps_Hybrid
D3 Net-_D3-Pad1_ ROW0 D
D5 Net-_D5-Pad1_ ROW0 D
MX5 COL4 Net-_D5-Pad1_ MX-NoLED-MX_Alps_Hybrid
D2 Net-_D2-Pad1_ ROW0 D
MX2 COL1 Net-_D2-Pad1_ MX-NoLED-MX_Alps_Hybrid
D1 Net-_D1-Pad1_ ROW0 D
MX1 COL0 Net-_D1-Pad1_ MX-NoLED-MX_Alps_Hybrid
MX13 COL12 Net-_D13-Pad1_ MX-NoLED-MX_Alps_Hybrid
D13 Net-_D13-Pad1_ ROW0 D
D12 Net-_D12-Pad1_ ROW0 D
MX12 COL11 Net-_D12-Pad1_ MX-NoLED-MX_Alps_Hybrid
D11 Net-_D11-Pad1_ ROW0 D
MX11 COL10 Net-_D11-Pad1_ MX-NoLED-MX_Alps_Hybrid
MX15 COL14 Net-_D15-Pad1_ MX-NoLED-MX_Alps_Hybrid
D15 Net-_D15-Pad1_ ROW0 D
D14 Net-_D14-Pad1_ ROW0 D
MX14 COL13 Net-_D14-Pad1_ MX-NoLED-MX_Alps_Hybrid
C5 VCC GND 0.1u
MX64 COL9 Net-_D64-Pad1_ MX-NoLED-MX_Alps_Hybrid
D64 Net-_D64-Pad1_ ROW4 D
MX65 COL10 Net-_D65-Pad1_ MX-NoLED-MX_Alps_Hybrid
D65 Net-_D65-Pad1_ ROW4 D
D67 Net-_D67-Pad1_ ROW4 D
MX67 COL12 Net-_D67-Pad1_ MX-NoLED-MX_Alps_Hybrid
U1 NC_05 VCC D- D+ GND Net-_C11-Pad2_ VCC COL0 COL1 COL2 COL3 COL7 RESET VCC GND XTAL2 XTAL1 SCL SDA COL8 COL9 COL11 GND VCC COL10 COL12 COL13 COL4 COL5 COL6 ROT_A ROT_B Net-_R7-Pad2_ VCC GND COL14 ROW4 ROW3 ROW2 ROW1 ROW0 NC_06 GND VCC ATmega32U4-AU
D70 R_ENC ROW2 D
OL1 SDA SCL VCC GND OLED-kbd
.end
